Commit message: fix rviz sim file names

File: src/main_arm_control/urdf/framemodel.urdf (robot description, URDF)
Before this commit: robot framemodel, 3 links, 2 joints
Links:
- removed link parachute_bag
Joints:
- removed joint bag_to_frame
